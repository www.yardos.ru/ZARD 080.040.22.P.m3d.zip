# KOMPAS-3D part (ZARD 080.040.22.P.m3d)

Model tree:
1. Операция без истории:1

Texts:
  ЗАРД 080.040.22-ХХ.Р
  Кран шаровой фланцевый
  ООО "ИК Энерпред-Ярдос"